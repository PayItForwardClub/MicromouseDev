# Keil uVision project KB.uvproj, settings and files
target RaiseYourARM2015 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: KB
  AfterMake: fromelf --bin --output .\RYA2015.bin .\Objects\KB.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: PART_TM4C123GH6PM,rvmdk
  c include: .\Include;E:\TivaWare_C_Series-2.1.0.12573
  memory RVCT4: ROM 0x1000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./Source/: startup_rvmdk.S
  group Battery
    ./Source/Battery/: Battery.c
  group Bluetooth
    ./Source/Bluetooth/: Bluetooth.c uartstdio.c
  group IR
    ./Source/IR/: IR.c
  group Button
    ./Source/Button/: Button.c
  group Buzzer
    ./Source/Buzzer/: Buzzer.c
  group Eeprom
    ./Source/Eeprom/: EEPROM.c Parameters.c
  group QEI
    ./Source/QEI/: qei.c
  group STR
    ./Source/STR/: Control_initialize.c rt_nonfinite.c rtGetInf.c rtGetNaN.c speed_control.c STR_Indirect.c Uocluong.c
  group WallFollow
    ./Source/WallFollow/: PID.c WallFollow.c
  group Timer
    ./Source/Timer/: Timer.c
  group Application
    ./Source/: main.c SystemConfig.c
  group TivaLibrary
    E:/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
  group ImageProcess
    ./Source/ImageProcess/: PositionControl.c
